## Kconfig.debug
```kconfig
config INT2FPSTR_KUNIT_TEST
	tristate "Test int2fpstr library" if !KUNIT_ALL_TESTS
	depends on KUNIT
	default KUNIT_ALL_TESTS
```
